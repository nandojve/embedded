# Keil uVision project https_server_demo.uvproj, settings and files
target https_server_demo_flash (ARM-ADS)
  device: STM32F439NI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: https_server_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1
  c define: STM32F429xx USE_STM324x9I_EVAL USE_HAL_DRIVER
  c include: ..\src;..\..\..\..\common\cmsis\include;..\..\..\..\common\st\devices\stm32f4xx;..\..\..\..\common\st\boards;..\..\..\..\common\st\boards\common;..\..\..\..\common\st\boards\stm324x9i_eval;..\..\..\..\common\st\stm32f4xx_hal_driver\inc;..\..\..\..\common\freertos\include;..\..\..\..\common\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f439_flash.sct
  group Demo Sources
    ./: startup_stm32f439xx.s retarget.c
    ../src/: system_stm32f4xx.c stm32f4xx_it.c main.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h tcp_ip_stack_config.h tls_config.h crypto_config.h freertosconfig.h stm32f4xx_hal_conf.h stm32f4xx_it.h
  group Common Sources
    ../../../../../common/: endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.c tcp_ip_stack_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c ping.c
    ../../../../../cyclone_tcp/drivers/: stm32f4x9_eth.c dp83848.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c icmpv6.c mld.c ndp.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.c dhcpv6_relay.c dhcpv6_common.c dhcpv6_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
    ../../../../../cyclone_tcp/http/: http_server.c mime.c ssi.c
    ../../../../../cyclone_tcp/smtp/: smtp_client.c
    ../../../../../cyclone_tcp/icecast/: icecast_client.c
    ../../../../../cyclone_tcp/std_services/: echo.c discard.c chargen.c daytime.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.h tcp_ip_stack_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h ping.h
    ../../../../../cyclone_tcp/drivers/: stm32f4x9_eth.h dp83848.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h icmpv6.h mld.h ndp.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.h dhcpv6_relay.h dhcpv6_common.h dhcpv6_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
    ../../../../../cyclone_tcp/http/: http_server.h mime.h ssi.h
    ../../../../../cyclone_tcp/smtp/: smtp_client.h
    ../../../../../cyclone_tcp/icecast/: icecast_client.h
    ../../../../../cyclone_tcp/std_services/: echo.h discard.h chargen.h daytime.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_client.c tls_server.c tls_common.c tls_record.c tls_io.c tls_misc.c tls_cache.c ssl_common.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: tls.h tls_cipher_suites.h tls_client.h tls_server.h tls_common.h tls_record.h tls_io.h tls_cache.h tls_misc.h ssl_common.h
  group CycloneCrypto Sources
    ../../../../../cyclone_crypto/: base64.c md2.c md4.c md5.c ripemd128.c ripemd160.c sha1.c sha224.c sha256.c sha384.c sha512.c sha512_224.c sha512_256.c tiger.c whirlpool.c hmac.c rc4.c rc6.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c cipher_mode_ecb.c cipher_mode_cbc.c cipher_mode_cfb.c cipher_mode_ofb.c cipher_mode_ctr.c cipher_mode_ccm.c cipher_mode_gcm.c dh.c rsa.c dsa.c ec.c ec_curves.c ecdh.c ecdsa.c pkcs5.c mpi.c mpi_asm_keil_cortex_m3.s asn1.c oid.c x509.c pem.c yarrow.c
  group CycloneCrypto Headers
    ../../../../../cyclone_crypto/: crypto.h base64.h md2.h md4.h md5.h ripemd128.h ripemd160.h sha1.h sha224.h sha256.h sha384.h sha512.h sha512_224.h sha512_256.h tiger.h whirlpool.h hmac.h rc4.h rc6.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h cipher_mode_ecb.h cipher_mode_cbc.h cipher_mode_cfb.h cipher_mode_ofb.h cipher_mode_ctr.h cipher_mode_ccm.h cipher_mode_gcm.h dh.h rsa.h dsa.h ec.h ec_curves.h ecdh.h ecdsa.h pkcs5.h mpi.h asn1.h oid.h x509.h pem.h yarrow.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/rvds/arm_cm4f/: port.c
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../common/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/rvds/arm_cm4f/: portmacro.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group STM324x9I-EVAL Sources
    ../../../../common/st/boards/stm324x9i_eval/: stm324x9i_eval.c stm324x9i_eval_sram.c stm324x9i_eval_sdram.c stm324x9i_eval_io.c stm324x9i_eval_lcd.c
    ../../../../common/st/boards/components/stmpe811/: stmpe811.c
    ../../../../common/st/boards/components//stmpe1600//: stmpe1600.c
  group STM324x9I-EVAL Headers
    ../../../../common/st/boards/stm324x9i_eval/: stm324x9i_eval.h stm324x9i_eval_sram.h stm324x9i_eval_sdram.h stm324x9i_eval_io.h stm324x9i_eval_lcd.h
    ../../../../common/st/boards/components/stmpe811/: stmpe811.h
    ../../../../common/st/boards/components//stmpe1600//: stmpe1600.h
  group STM32F4xx HAL Drivers Sources
    ../../../../common/st/stm32f4xx_hal_driver/src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group STM32F4xx HAL Drivers Headers
    ../../../../common/st/stm32f4xx_hal_driver/inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
target https_server_demo_sram (ARM-ADS)
  device: STM32F439NI STMicroelectronics
  cpu: as above
  output: https_server_demo_sram
  BeforeMake: as above
  c flags: Optim=1
  c define: STM32F429xx USE_STM324x9I_EVAL USE_HAL_DRIVER
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f439_sram.sct
